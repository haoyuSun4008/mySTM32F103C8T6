# Keil uVision project prjOne.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: myPrj +hex
  c flags: Optim=1
  c include: C:\Users\Administrator\Desktop\stm32f103c8t6\MCAL;E:\Keil\ARM\ARMCC\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
  group ASW
    ./ASW/: TestCase1.c TestCase1.h
  group BSW
    ./BSW/: main.c main.h startup_stm32f10x_md.s
  group CSW
    ./CSW/: clock.c clock.h hwio.c hwio.h timer.c timer.h interrupt.c interrupt.h
  group MCAL
    ./MCAL/: core_cm3.c core_cm3.h misc.c misc.h stm32f10x.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_tim.c stm32f10x_tim.h system_stm32f10x.c system_stm32f10x.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
